# Keil uVision project RFID.uvproj, settings and files
target RFID (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: RFID +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\includes
  group App
    ./App/: main.c UART.c RC522.c
  group Hard
    ./Hard/: init.c UART_hard.c SPI_hard.c
  group Lib
    ./Lib/: kfifo.c Conf_tny.A51
  group includes
    ./includes/: common.h DataType.h init.h kfifo.h app.h stc12c5a.h RC522.h Hard.h
